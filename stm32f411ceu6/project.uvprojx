# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, STM32F411xE
  c include: ..\rt-thread\components\drivers\spi;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\include;..\rt-thread\libcpu\arm\cortex-m4;.;board\board_drivers\spi_flash_w25q64;..\rt-thread\components\libc\posix\io\poll;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;board;..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\rt-thread\components\libc\compilers\common\include;packages\MultiButton-v1.1.0;..\rt-thread\components\drivers\spi\sfud\inc;..\rt-thread\libcpu\arm\common;hal;..\rt-thread\components\drivers\include;..\libraries\HAL_Drivers;..\rt-thread\components\fal\inc;..\rt-thread\components\libc\posix\io\epoll;board\ports;board\CubeMX_Config\Inc;..\rt-thread\components\libc\compilers\common\extension;board\board_drivers;..\rt-thread\components\finsh;applications;..\rt-thread\components\libc\posix\ipc;..\libraries\HAL_Drivers\CMSIS\Include;..\libraries\HAL_Drivers\config;..\rt-thread\components\libc\posix\io\eventfd;..\libraries\HAL_Drivers\drv_flash
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group BoardDrivers
    board/board_drivers/spi_flash_w25q64/: drv_soft_spi_flash.c drv_hw_spi_flash.c
  group Compiler
    ../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    ../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../rt-thread/components/drivers/core/: device.c
    ../rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../rt-thread/components/drivers/misc/: pin.c
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group Fal
    ../rt-thread/components/fal/src/: fal_partition.c fal_rtt.c fal_flash.c fal.c
    ../rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Finsh
    ../rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group hal
    hal/: hal_button.c hal.c
  group Kernel
    ../rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_flash.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group MultiButton
    packages/MultiButton-v1.1.0/: multi_button.c
  group ports
    board/ports/: fal_spi_flash_sfud_port.c
